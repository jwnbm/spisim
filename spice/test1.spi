* RC Circuit
*V1 1 0 DC 5V
VPULSE 1 0 PULSE(-1mV 1mV 2ns 2ns 2ns 50ns 100ns)
R1 1 2 1k
C1 2 0 1uF
